# IAR project Audio_playback_and_record.ewp, settings and files
configuration MEDIA_IntFLASH (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS; MEDIA_IntFLASH
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\Libraries\CMSIS\Include; ..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\Libraries\STM32_USB_OTG_Driver\inc; ..\Utilities\STM32F4-Discovery; ..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F4-Discovery_Audio_IntFLASH.bin
  ILINK.IlinkOutputFile: STM32F4-Discovery_Audio_IntFLASH.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MEDIA_USB_KEY (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; USE_USB_OTG_FS; MEDIA_USB_KEY
  ICCARM.CCIncludePath2: ..\; ..\inc; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc; ..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc; ..\..\..\Libraries\STM32_USB_OTG_Driver\inc; ..\..\..\Utilities\STM32F4-Discovery; ..\..\..\Utilities\Third_Party\fat_fs\inc
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: STM32F4-Discovery_Audio_USB.bin
  ILINK.IlinkOutputFile: STM32F4-Discovery_Audio_USB.out
  group EWARM
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group FAT_FS
    ../../../Utilities/Third_Party/fat_fs/src/: fattime.c ff.c
  group STM32_USB_HOST_Library/Class/MSC
    ../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group STM32_USB_HOST_Library/Core
    ../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group STM32_USB_OTG_Driver
    ../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group STM32F4-Discovery
    ../Utilities/STM32F4-Discovery/: libPDMFilter_IAR.a stm32f4_discovery.c stm32f4_discovery_audio_codec.c stm32f4_discovery_lis302dl.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group User
    ../src/: audio_sample.c main.c stm32f4xx_it.c system_stm32f4xx.c usb_bsp.c usbh_usr.c waveplayer.c waverecorder.c
